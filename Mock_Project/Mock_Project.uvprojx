# Keil uVision project Mock_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Library_For_Mock
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: C:\Users\trung\OneDrive\Desktop\Mock Project\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c
    ../src/: Basic_Function.c Clock.c IRQ_Function.c LPIT.c LPSPI.c LPUART_Function.c Mock_Function.c SysTick.c
    ../inc/: Clock.h IRQ.h LPIT.h LPSPI.h LPUART.h Mock_Library.h SysTick.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.0
